Properties of the parts of a building model (IFC2X3)

# File
Description: IFC2X3
File name: CORE WALL MINI.IFC
Time: 2026-01-30T15:49:28+02:00
Written by: IfcOpenShell 0.8.4
Made in: Bonsai 0.8.4

# IfcSite, Default Site
RefLatitude: 0, 0, 0, 0; RefLongitude: 0, 0, 0, 0; RefElevation: 0 m

# IfcBuildingStorey, Default Storey
In: Default Building
Elevation: 0 m
